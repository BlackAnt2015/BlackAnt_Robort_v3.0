# Keil uVision project Project.uvprojx, settings and files
target TCL_STM32F103RB (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: trochili +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.0.0\CMSIS\Include;C:\Keil_v5\ARM\Pack\Keil\STM32F1xx_DFP\2.2.0\Device\StdPeriph_Driver\inc;C:\Keil_v5\ARM\PACK\Keil\STM32F1xx_DFP\2.2.0\Device\Include;..\..\board\Nucleo-f103rb\STM32F10x_Firmware_Library_Adapter;..\..\kernel\inc;..\..\kernel\inc\arch;..\..\kernel\inc\cpu;..\..\kernel\inc\ipc;..\..\example;C:\Keil_v5\ARM\Pack\Keil\STM32F1xx_DFP\2.2.0\Device;C:\Keil_v5\ARM\Pack\Keil\STM32F1xx_DFP\2.2.0\Device\Include;C:\Keil_v5\ARM\Pack\Keil\STM32F1xx_DFP\2.2.0\Device\Source;C:\Keil_v5\ARM\Pack\Keil\STM32F1xx_DFP\2.2.0\Device\StdPeriph_Driver\src;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include;C:\Keil_v5\ARM\Pack\Keil\STM32F1xx_DFP\2.2.0\Device\StdPeriph_Driver\templates;C:\Keil_v5\ARM\Pack\ARM\CMSIS;..\..\nmea_decode\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STM32F10x_CMSIS
    C:/Keil_v5/ARM/Pack/Keil/STM32F1xx_DFP/2.2.0/Device/Source/: system_stm32f10x.c
    C:/Keil_v5/ARM/Pack/Keil/STM32F1xx_DFP/2.2.0/Device/Source/ARM/: startup_stm32f10x_md.s
  group STM32F10x_FWLib
    C:/Keil_v5/ARM/Pack/Keil/STM32F1xx_DFP/2.2.0/Device/StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group NucleoF103RB_BSP
    ../../board/Nucleo-f103rb/: bsp.c
  group TROCHILI
    ../../kernel/src/arch/: tcl.arm.cm3.keil.asm tcl.arm.cm3.c
    ../../kernel/src/cpu/: tcl.stm32.f103rb.c
    ../../kernel/src/: tcl.debug.c tcl.irq.c tcl.kernel.c tcl.memory.c tcl.object.c tcl.pool.c tcl.thread.c tcl.timer.c
    ../../kernel/src/ipc/: tcl.flags.c tcl.ipc.c tcl.mailbox.c tcl.message.c tcl.mutex.c tcl.semaphore.c
  group example_thread
    ../../example/book_chapter_2_thread/: thread_activate_deactivate.c thread_change_priority.c thread_change_slice.c thread_delay_undelay.c thread_init.c thread_suspend_resume.c thread_yield.c
  group example_semaphore
    ../../example/book_chapter_4_semaphore/: semaphore_example1.c semaphore_example2.c semaphore_example3_isr.c semaphore_example4.c semaphore_example5_reset.c semaphore_example6_flush.c semaphore_example7_delete.c semaphore_example8_abort.c semaphore_example9_timeout.c
  group example_mutex
    ../../example/book_chapter_5_mutex/: mutex_example1.c mutex_example2_reset.c mutex_example3_flush.c mutex_example4_delete.c mutex_example5_abort.c
  group example_mailbox
    ../../example/book_chapter_6_mailbox/: mailbox_example1.c mailbox_example2_isr.c mailbox_example3.c mailbox_example4.c mailbox_example5_reset.c mailbox_example6_broadcast.c mailbox_example7_flush.c mailbox_example8_delete.c mailbox_example9_abort.c
  group example_message
    ../../example/book_chapter_7_message/: message_example1.c message_example2_isr.c message_example3.c message_example4.c message_example5_reset.c message_example6_broadcast.c message_example7_flush.c message_example8_delete.c message_example9_abort.c
  group example_flags
    ../../example/book_chapter_8_flags/: flags_example1.c flags_example2_isr.c flags_example3_reset.c flags_example4_flush.c flags_example5_delete.c flags_example6_abort.c
  group example_timer
    ../../example/book_chapter_9_timer/: user_timer_basic_example.c user_timer_config_example.c user_timer_lagticks_example.c
  group example_irq
    ../../example/book_chapter_10_irq/: irq_example1.c irq_example2.c
  group example_memory
    ../../example/book_chapter_11_memory/: memory_buddy_example.c memory_pool_example.c
  group example_board
    ../../example/book_chapter_13_board/: board_example.c
    ../../example/book_chapter_1_rtos/: rtos_example.c
  group app
    ../../app/: main.c main.h beep.c beep.h common.c common.h light.c motor.c parser.c receiver.c steer.c light.h motor.h parser.h receiver.h steer.h gps.c gps.h sender.c sender.h
  group bsp
    ../../bsp/: BSP_Gpio.c BSP_Gpio.h BSP_Common.h BSP_Common.c BSP_ADC.C BSP_GPS.c BSP_Pwm.c BSP_Systick.c BSP_Timer.c BSP_Uart.c BSP_ADC.h BSP_GPS.h BSP_Pwm.h BSP_Systick.h BSP_Timer.h BSP_Uart.h
  group nmealib
    ../../nmea_decode/src/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
    ../../nmea_decode/include/nmea/: config.h context.h generate.h generator.h gmath.h info.h nmea.h parse.h parser.h sentence.h time.h tok.h units.h
