# Keil uVision project Project.uvprojx, settings and files
target TCL_GD32F450VE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GD32F450VK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: trochili +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F4XX
  c include: C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.0.0\CMSIS\Include;C:\Keil_v5\ARM\PACK\GigaDevice\GD32F4xx_DFP\1.0.1\Device\Include;C:\Keil_v5\ARM\PACK\GigaDevice\GD32F4xx_DFP\1.0.1\Device\Firmware\Peripherals\inc;..\..\board\Colibri450;..\..\board\Colibri450\GD32F4xx_Firmware_Library_Adapter;..\..\kernel\inc;..\..\kernel\inc\arch;..\..\kernel\inc\cpu;..\..\kernel\inc\ipc;..\..\example
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group GD32F450_CMSIS
    C:/Keil_v5/ARM/PACK/GigaDevice/GD32F4xx_DFP/1.0.1/Device/Source/: system_gd32f4xx.c
    C:/Keil_v5/ARM/PACK/GigaDevice/GD32F4xx_DFP/1.0.1/Device/Source/ARM/: startup_gd32f450.s
  group GD32F450_FWLIB
    C:/Keil_v5/ARM/PACK/GigaDevice/GD32F4xx_DFP/1.0.1/Device/Firmware/Peripherals/src/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Colibri450_BSP
    ../../board/Colibri450/: colibri_bsp.c colibri_bsp_key.c colibri_bsp_led.c colibri_bsp_uart.c
  group TROCHILI
    ../../kernel/src/arch/: tcl.arm.cm4.c tcl.arm.cm4.keil.asm
    ../../kernel/src/cpu/: tcl.gd32.f450ve.c
    ../../kernel/src/: tcl.kernel.c tcl.thread.c tcl.timer.c tcl.memory.c tcl.pool.c tcl.object.c tcl.irq.c tcl.debug.c
    ../../kernel/src/ipc/: tcl.ipc.c tcl.flags.c tcl.mailbox.c tcl.message.c tcl.mutex.c tcl.semaphore.c
  group example_thread
    ../../example/book_chapter_2_thread/: thread_activate_deactivate.c thread_change_priority.c thread_change_slice.c thread_delay_undelay.c thread_init.c thread_suspend_resume.c thread_yield.c
  group example_semaphore
    ../../example/book_chapter_4_semaphore/: semaphore_example1.c semaphore_example2.c semaphore_example3_isr.c semaphore_example4.c semaphore_example5_reset.c semaphore_example6_flush.c semaphore_example7_delete.c semaphore_example8_abort.c semaphore_example9_timeout.c
  group example_mutex
    ../../example/book_chapter_5_mutex/: mutex_example1.c mutex_example2_reset.c mutex_example3_flush.c mutex_example4_delete.c mutex_example5_abort.c
  group example_mailbox
    ../../example/book_chapter_6_mailbox/: mailbox_example1.c mailbox_example2_isr.c mailbox_example3.c mailbox_example4.c mailbox_example5_reset.c mailbox_example6_broadcast.c mailbox_example7_flush.c mailbox_example8_delete.c mailbox_example9_abort.c
  group example_message
    ../../example/book_chapter_7_message/: message_example1.c message_example2_isr.c message_example3.c message_example4.c message_example5_reset.c message_example6_broadcast.c message_example7_flush.c message_example8_delete.c message_example9_abort.c
  group example_flags
    ../../example/book_chapter_8_flags/: flags_example1.c flags_example2_isr.c flags_example3_reset.c flags_example4_flush.c flags_example5_delete.c flags_example6_abort.c
  group example_timer
    ../../example/book_chapter_9_timer/: user_timer_basic_example.c user_timer_config_example.c user_timer_lagticks_example.c
  group example_irq
    ../../example/book_chapter_10_irq/: irq_example1.c irq_example2.c
  group example_memory
    ../../example/book_chapter_11_memory/: memory_buddy_example.c memory_pool_example.c
  group example_board
    ../../example/book_chapter_13_board/: board_example.c
